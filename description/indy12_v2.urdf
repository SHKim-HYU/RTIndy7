Commit message: update

File: description/indy12_v2.urdf (robot description, URDF)
Before this commit: robot indy12_v2, 9 links, 8 joints
Links:
- link link4: mass 5.10779343  -> 5.10779343
